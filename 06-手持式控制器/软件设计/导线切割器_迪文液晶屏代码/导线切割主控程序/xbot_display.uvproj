# Keil uVision project xbot_display.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: xbot_display +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Includes\STM32_CMSIS;.\Includes\STM32F3_StdPeriph;.\Includes\DataTypeRealize;.\Includes\STM32_Driver;.\Includes\Protocol;.\Includes\App;.\Includes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./source/User/: main.cpp
  group App
    ./source/App/: MasterCtrlApp.cpp
  group Protocol
    ./source/Protocol/: LCDdisplay.cpp TerminalControl.cpp
  group DataTypeRealize
    ./source/DataTypeRealize/: LEDLighter.cpp WatchDog.cpp DataChain.cpp SerialPort.cpp Timer.cpp Key.cpp
  group STM32_Driver
    ./source/STM32_Driver/: STM32_GpioInit.c STM32F10x_PriorityControl.c STM32_SysTick.c ADC.c
  group SEM32F3_StdPeriph
    ./source/STM32F3_StdPeriph/: misc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_iwdg.c stm32f10x_conf.c stm32f10x_adc.c stm32f10x_dma.c
  group STM32F3_CMSIS
    ./source/STM32_CMSIS/: startup_stm32f10x_md.s system_stm32f10x.c
  group Redme
    ./ReadMe/: readme.txt
