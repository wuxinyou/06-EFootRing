# Keil uVision project Project.uvproj, settings and files
target Peoject (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project.hex +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: .\Includes\STM32_CMSIS;.\Includes\STM32_Driver;.\Includes\Protocol;.\Includes\App;.\Includes;.\Includes\STM32_StdPeriph;.\Includes\DataType;.\Includes\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./source/User/: main.cpp
  group App
    ./source/App/: Process.cpp
  group Protocol
    ./source/Protocol/: TerminalControl.cpp LCDdisplay.cpp oled.c
  group DataType
    ./source/DataType/: DataChain.cpp IoOut.cpp Key.cpp SerialPort.cpp Timer.cpp sqStack.cpp SpiPort.cpp
  group STM32_Driver
    ./source/STM32_Driver/: STM32_SysTick.c STM32_ADC.c STM32_Priority.c STM32_GPIO.c
  group STM32_StdPeriph
    ./source/STM32_StdPeriph/: misc.c stm32f10x_adc.c stm32f10x_conf.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_pwr.c stm32f10x_exti.c stm32f10x_rtc.c stm32f10x_spi.c
  group STM32_CMSIS
    ./source/STM32_CMSIS/: system_stm32f10x.c startup_stm32f10x_md.s
  group ReadMe
    ./: ReadMe.txt
